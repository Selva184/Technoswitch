# IAR project Backup of BLE_SensorDemo_NWK.ewp, settings and files
configuration BLE_SensorDemo_NWK_UART (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=1; DEBUG=1; ENABLE_USART=1; BTLE_NWK_COPROC; UART_INTERFACE
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\..\Library\STM32L\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\Library\STM32L\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32Lxx_Nucleo\inc; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32Lxx_BlueNRG1\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\HAL\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI\includes; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_NWK_UART.hex
  ILINK.IlinkOutputFile: BLE_SensorDemo_UART.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration BLE_SensorDemo_NWK_UART_HWFlowCtrl (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=1; DEBUG=1; ENABLE_USART=1; BTLE_NWK_COPROC; UART_INTERFACE; DTM_UART_HW_FLOW_CTRL
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_NWK_UART_HWFlowCtrl.hex
configuration BLE_SensorDemo_NWK_UART_LowPower (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=0; ENABLE_MICRO_SLEEP=1; SYSCLK_MSI=1; BTLE_NWK_COPROC; UART_INTERFACE; SENSORDEMO_NWK
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_NWK_UART_LowPower.hex
configuration BLE_SensorDemo_NWK_SPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=1; DEBUG=1; ENABLE_USART=1; BTLE_NWK_COPROC; SPI_INTERFACE
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_NWK_SPI.hex
configuration BLE_SensorDemo_NWK_SPI_LowPower (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=0; SYSCLK_MSI=1; ENABLE_MICRO_SLEEP=1; BTLE_NWK_COPROC; SPI_INTERFACE; SENSORDEMO_NWK
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_NWK_SPI_LowPower.hex
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../src/: BLE_SensorDemo_NWK_main.c gatt_db.c hci_parser.c sensor.c stm32xx_it.c user_timer.c
  group Drivers/BSP/STM32L4xx_BlueNRG1
    ../../../../Library/STM32L/Drivers/BSP/STM32Lxx_BlueNRG1/src/: SDK_EVAL_GPIO.c SDK_EVAL_Spi.c SDK_EVAL_Uart.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../Library/STM32L/Drivers/BSP/STM32Lxx_Nucleo/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Drivers/CMSIS
    ../../../../Library/STM32L/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../Library/STM32L/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c
  group Middlewares/STM32_BlueNRG1/HAL
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/HAL/src/: clock.c gp_timer.c list.c low_power.c osal.c
  group Middlewares/STM32_BlueNRG1/HCI
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/: bluenrg1_events.c bluenrg1_hci_le.c hci.c
  group Middlewares/STM32_BlueNRG1/HCI/Controller
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
