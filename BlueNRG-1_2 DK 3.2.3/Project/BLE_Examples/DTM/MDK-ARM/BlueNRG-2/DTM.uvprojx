# Keil uVision project DTM.uvprojx, settings and files
target SPI (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IROM(0x10040000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DTM_SPI +hex
  AfterMake: fromelf.exe --bin SPI\Objects\DTM_SPI.axf --output SPI\Objects\DTM_SPI.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: SPI_INTERFACE WATCHDOG WATCHDOG_TIME=1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\hal\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
  group DTM_Updater
    ../../DTM_Updater/: DTM_Updater_SPI.c DTM_Updater_UART.c
  group Hal
    ../../../../../Library/hal/src/: context_switch.s fifo.c miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_dle_api_stubs.c stack_priv_api_stubs.c stack_sc_api_stubs.c stack_slvonly_api_stubs.c stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
  group User
    ../../src/: BlueNRG1_it.c cmd.c DTM_boot.c DTM_burst.c DTM_cmd_db.c DTM_cmds.c DTM_main.c hci_parser.c hw_config.c transport_layer.c
target SPI_NOUPDATER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: DTM_SPI_NOUPDATER +hex
  AfterMake: fromelf.exe --bin SPI_NOUPDATER\Objects\DTM_SPI_NOUPDATER.axf --output SPI_NOUPDATER\Objects\DTM_SPI_NOUPDATER.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
target UART (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: DTM_UART +hex
  AfterMake: fromelf.exe --bin UART\Objects\DTM_UART.axf --output UART\Objects\DTM_UART.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: UART_INTERFACE WATCHDOG WATCHDOG_TIME=1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\hal\inc;..\..\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
target UART_SLEEP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: DTM_UART_SLEEP +hex
  AfterMake: fromelf.exe --bin UART_SLEEP\Objects\DTM_UART_SLEEP.axf --output UART_SLEEP\Objects\DTM_UART_SLEEP.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: UART_INTERFACE WATCHDOG WATCHDOG_TIME=1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION UART_SLEEP BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
target UART_NOUPDATER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: DTM_UART_NOUPDATER +hex
  AfterMake: fromelf.exe --bin UART_NOUPDATER\Objects\DTM_UART_NOUPDATER.axf --output UART_NOUPDATER\Objects\DTM_UART_NOUPDATER.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
target UART_Throughput (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: DTM_UART_Throughput +hex
  AfterMake: fromelf.exe --bin UART_Throughput\Objects\DTM_UART_Throughput.axf --output UART_Throughput\Objects\DTM_UART_Throughput.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: UART_INTERFACE WATCHDOG WATCHDOG_TIME=1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION DTM_THROUGHPUT_CONF=1 BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x2000 "
